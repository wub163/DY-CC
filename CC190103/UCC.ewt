<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\SYSTEM\jiami\jm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CORE\startup_stm32f429_439xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CORE\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>FWLIB</name>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_dma2d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_fmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_ltdc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLIB15\src\stm32f4xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>hj</name>
    <group>
      <name>bsp</name>
      <file>
        <name>$PROJ_DIR$\hujun\BSP\Bsp_Global.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\hujun\BSP\DMA.C</name>
      </file>
      <file>
        <name>$PROJ_DIR$\hujun\BSP\Modbus.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\hujun\BSP\MOTOR.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\hujun\BSP\NVIC.C</name>
      </file>
      <file>
        <name>$PROJ_DIR$\hujun\BSP\SCI.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>READ</name>
  </group>
  <group>
    <name>RTOS</name>
    <group>
      <name>board</name>
      <file>
        <name>$PROJ_DIR$\rtos\free\source\heap_5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\rtos\free\source\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\rtos\free\source\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\rtos\free\source\portmacro.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\readme.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\include\semphr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rtos\free\source\timers.c</name>
    </file>
  </group>
  <group>
    <name>SYSTEM</name>
    <file>
      <name>$PROJ_DIR$\BSP\CAN\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\CAN\CAN_MP3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\CAN\CAN_PE_XKD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\CAN\CAN_RMDS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\cpuinfo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\GPIO\GPIO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SYSTEM\TM1638\TM1638.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\rtos\free\include\FreeRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hujun\App\Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hujun\App\Main_Task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hujun\App\Main_Task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hujun\App\Motor_Task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hujun\App\Motor_Task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\set.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f429xG.icf</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\version.txt</name>
  </file>
  <file>
    <name>$PROJ_DIR$\USER\&#x4e0A;&#x4F4D;&#x673A;&#x534F;&#x8BAe;.txt</name>
  </file>
</project>


