# IAR project UCC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F429_439xx; USE_STDPERIPH_DRIVER; ARM_MATH_CM4
  ICCARM.CCIncludePath2: FWLIB15\inc; SYSTEM\delay; SYSTEM\sys; BSP\usart; BSP\CAN; BSP\GPIO; BSP\NVIC; BSP\SRAM; BSP\24CXX; BSP\SPI; BSP\lcd; BSP\dy; USER; BSP\ram; MALLOC; BSP\485moto; CORE; rtos\include; rtos\source; BSP\sdram; BSP\TFTLCD; BSP\yaokong; ETH\lwip-1.4.1\src\include; ETH\lwip-1.4.1\src\include\ipv4; ETH\lwip-1.4.1\lwip_comm; ETH\lwip-1.4.1\arch; ETH\lwip-1.4.1; ETH\BSP; BSP\sensor; SYSTEM\LED; hujun\Module; rtos\free\include; rtos\free\source; hujun\App; hujun\BSP\MR15; hujun\BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: rtos\free\include
  OBJCOPY.OOCOutputFile: UCC.hex
  ILINK.IlinkOutputFile: ext.out
  ILINK.IlinkIcfFile: stm32f429xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: version.txt
    USER/: 上位机协议.txt
  group BSP
    SYSTEM/jiami/: jm.c
    CORE/: startup_stm32f429_439xx.s system_stm32f4xx.c
  group FWLIB
    FWLIB15/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group hj/bsp
    hujun/BSP/: Bsp_Global.c DMA.C Modbus.c MOTOR.c NVIC.C SCI.c
  group RTOS
    rtos/free/source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    rtos/free/include/: semphr.h
  group RTOS/board
    rtos/free/source/: heap_5.c port.c portasm.s portmacro.h
  group SYSTEM
    BSP/CAN/: can.c CAN_MP3.c CAN_PE_XKD.c CAN_RMDS.c
    USER/: cpuinfo.c
    BSP/GPIO/: GPIO.c
    SYSTEM/TM1638/: TM1638.c
  group USER
    rtos/free/include/: FreeRTOSConfig.h
    hujun/App/: Main.c Main_Task.c Main_Task.h Motor_Task.c Motor_Task.h
    USER/: set.h
    ./: stm32f429xG.icf
